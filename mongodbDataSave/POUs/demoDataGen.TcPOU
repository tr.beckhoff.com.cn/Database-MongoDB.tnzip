PROGRAM demoDataGen
VAR
	t:REAL;
	dataout:REAL;
END_VAR

// 模拟信号发生器
t:=t+0.1;
IF t > 100 THEN
	t:=0;
END_IF
dataout:=SIN(t);

END_PROGRAM
