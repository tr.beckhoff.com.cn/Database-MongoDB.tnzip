TYPE demoDUT :
STRUCT
	timedata:TIMESTRUCT;
	realdata:REAL;
	eventdiscription:STRING;
END_STRUCT
END_TYPE
